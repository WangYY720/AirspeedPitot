# Keil uVision project BH-F103.uvprojx, settings and files
target AirspeedPitot_Transmitter (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AirspeedPitot_Transmitter +hex
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\adc;..\..\User\delay;..\..\User\pwm;..\..\User\tim;..\..\User\FreeRTOS\include;..\..\User\sys;..\..\User\FreeRTOS\portable\RVDS\ARM_CM3;..\..\User\capture;..\..\Hardware\OLED;..\..\Hardware\MS4525
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/adc/: bsp_adc.c
    ../../User/usart/: bsp_usart.c usart.c
    ../../User/pwm/: pwm.c
    ../../User/tim/: tim.c
    ../../User/delay/: delay.c
    ../../User/sys/: sys.c
    ../../User/capture/: capture.c
  group DOC
    ../../Doc/: readme.txt
  group FREERTOS
    ../../User/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../User/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../User/FreeRTOS/portable/MemMang/: heap_4.c
  group HARDWARE
    ../../Hardware/OLED/: oled.c
    ../../Hardware/MS4525/: ioi2c.c ms4525do.c
